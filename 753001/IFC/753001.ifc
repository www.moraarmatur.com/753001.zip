Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Jonas\Documents\Cadfocus\Ostnor\2013\20131122_CAD-objekt_MMIX\ARBETSMAPP\753001\AutoCAD Architecture\753001.ifc
Time: 2013-11-29T17:06:43
Author: - -
Organization: Mora Armatur
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 753001
LongName: 753001
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 753001
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 753001, BUILDINGELEMENTPROXY(1)
In: 753001
Description: Mora MMIX W5 Kitchen/Basin mixer, Wallmounted 150c/c, outlet down
